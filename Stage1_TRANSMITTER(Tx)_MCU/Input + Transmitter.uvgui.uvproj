# Keil uVision project Input + Transmitter.uvgui.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: Input + Transmitter.uvgui
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: bus_encoder.c main.c peripherals.c transmitter_out .c tx_handler.c
